# Keil uVision project LiteOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LiteOS\OS_CONFIG;.\LiteOS\arch\cortex-m7;.\LiteOS\arch\include;.\LiteOS\kernel\include;.\LiteOS\kernel\base\include;.\LiteOS\kernel\extended\include;.\LiteOS\cmsis;.\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group User
    ./Src/: start_task.c led_task.c
  group LiteOS
    ./LiteOS/cmsis/2.0/: cmsis_liteos2.c
    ./LiteOS/arch/src/: los_hw.c los_hw_tick.c los_hwi.c
    ./LiteOS/arch/cortex-m7/keil/: los_dispatch_keil.S
    ./LiteOS/kernel/: los_init.c
    ./LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ./LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ./LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ./LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ./LiteOS/kernel/base/mem/membox/: los_membox.c
    ./LiteOS/kernel/base/misc/: los_misc.c
    ./LiteOS/kernel/base/om/: los_err.c
    ./LiteOS/kernel/extended/tickless/: los_tickless.c
    ./LiteOS/OS_CONFIG/: target_config.h
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F767IGTx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F767IGTx/STCubeGenerated/Inc/: stm32f7xx_it.h
software components: CMSIS:CORE 5.2.0, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:UART 1.2.6, Device:Startup 1.2.2
