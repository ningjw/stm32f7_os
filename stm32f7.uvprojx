# Keil uVision project stm32f7.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: stm32f7
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: .\ucos;.\Inc;.\STemWin\inc;.\STemWin\Config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group User
    ./Src/: task.c led_task.c round_robin_task.c uart1_printf.c sem_test_task.c flag_grp_task.c os_tmr.c arm_cortexM7lfsp_math.lib
  group Driver
    ./Src/: lcd_driver.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F767IGTx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F767IGTx/STCubeGenerated/Inc/: stm32f7xx_it.h
  group ucos
    ./ucos/: cpu_c.c os_cpu_c.c cpu_a.asm os_cpu_a.s
  group STemWin
    ./STemWin/OS/: GUI_X_OS.c
    ./STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c LCDConf_Lin_Template.c
    ./STemWin/Lib/: STemWin532_CM7_OS_Keil.lib
software components: CMSIS:CORE 5.2.0, Device:STM32Cube HAL:CRC 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:SRAM 1.2.6, Device:STM32Cube HAL:UART 1.2.6, Device:STM32Cube HAL:USART 1.2.6, Device:Startup 1.2.2, RTOS:uC/OS Common 1.0.0, RTOS:uC/OS Kernel 1.0.0
