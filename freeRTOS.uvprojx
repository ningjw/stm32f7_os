# Keil uVision project freeRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: freeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Inc;.\STemWinLibrary532\inc;.\STemWinLibrary532\Config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group User
    ./Src/: start_task.c led_task.c utility.c
    ./RTE/Device/STM32F767IGTx/STCubeGenerated/Inc/: stm32f7xx_hal_conf.h
  group Driver
    ./Src/: lcd_driver.c iic_driver.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F767IGTx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F767IGTx/STCubeGenerated/Inc/: stm32f7xx_it.h
  group STemWin
    ./STemWinLibrary532/OS/: GUI_X_OS.c
    ./STemWinLibrary532/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUIConf.h
    ./STemWinLibrary532/Lib/: STemWin532_CM7_OS_Keil.lib
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Coroutines 10.2.0, RTOS:Event Groups 10.2.0, RTOS:Heap 10.2.0, RTOS:Message Buffer 10.2.0, RTOS:Stream Buffer 10.2.0, RTOS:Timers 10.2.0, CMSIS:CORE 5.2.0, Device:STM32Cube HAL:CRC 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:SRAM 1.2.6, Device:STM32Cube HAL:UART 1.2.6, Device:Startup 1.2.2
